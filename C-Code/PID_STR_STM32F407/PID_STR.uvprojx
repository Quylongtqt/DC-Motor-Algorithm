# Keil uVision project PID_STR.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PID_STR
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000
  c include: ..\11_PID_STR_STM32F407;.\STM32F4xx_StdPeriph_Driver\src;.\STM32F4xx_StdPeriph_Driver\inc;.\Matlab_PID;.\Matlab_STR;.\Matlab_PID_Speed;.\Matlab_STR_Speed;.\Matlab_LQR
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: driver.c driver.h main.c system_timetick.c system_timetick.h variable_declare.h
  group STM32F4xx
    ./: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group Matlab_PID
    ./Matlab_PID/: pid.c pid_data.c
  group Matlab_PID_Speed
    ./Matlab_PID_Speed/: pid_speed.c pid_speed_data.c
  group Matlab_STR
    ./Matlab_STR/: rt_nonfinite.c rt_pow_snf.c rtGetInf.c rtGetNaN.c str.c str_data.c
  group Matlab_STR_Speed
    ./Matlab_STR_Speed/: str_speed.c str_speed_data.c
  group Matlab_LQR
    ./Matlab_LQR/: lqr.c lqr_data.c
  group Std_lib
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c
software components: CMSIS:CORE 5.1.1
