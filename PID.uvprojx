# Keil uVision project PID.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PID
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F410x,HSE_VALUE=8000000
  c include: ..\09_PID;.\Matlab;.\STM32F10x_StdPeriph_Driver\inc;.\STM32F10x_StdPeriph_Driver\src;.\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c driver.c system_timetick.c main.h driver.h
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
  group STM32F10x
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group Matlab
    ./Matlab/: pid.c pid.h pid_data.c
software components: CMSIS:CORE 5.1.1
